# Keil uVision project STM32_BareMetal_BlinkLed_Keil.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_BareMetal_BlinkLed_Keil +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\..\..\Keil\Packs\ARM\CMSIS\5.9.0\CMSIS\Core\Include;.\Core\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./Core/src/: main.c system_stm32f1xx.c gpio.c timer2.c
  group inc
    ./Core/inc/: gpio.h timer2.h
  group startup
    ./Startup/: startup_stm32f10x_md.s
